# Keil uVision project test1.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: ATSAMC21E18A Microchip
  pack: Microchip.SAMC21_DFP.3.8.119
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) IROM2(0x00400000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: test1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x400000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c
software components: CMSIS Driver:Flash:Custom 1.0.0, CMSIS Driver:SPI:Custom 1.0.0, CMSIS Driver:USART:Custom 1.0.0, CMSIS-Compiler:CORE 1.1.0, CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2, Device:Startup 3.8.0
